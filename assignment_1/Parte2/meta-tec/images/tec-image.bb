SUMMARY = "bitbake-layers recipe"
DESCRIPTION = "Recipe created by bitbake-layers"
LICENSE = "MIT"

require /home/maestria/rpi/meta-rpi/images/console-image.bb

export IMAGE_BASENAME = "tec-image"
